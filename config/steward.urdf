Commit message: Add xacro and URDF

File: config/steward.urdf (robot description, URDF)
Before this commit: robot warthog, 15 links, 14 joints
Links:
- link left_diff_unit_link: mass 50 -> None; geometry 
